# Keil uVision project stm32f0_91_bt.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0_91_bt
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./user/: main.c rtc.c tim_basic.c iwdg.c debug.c maxim_7219.c gpio.c uart8.c a_uart.c sys_clock.c uart7.c uart.c pa5_led.c pc13btn.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.2.3
